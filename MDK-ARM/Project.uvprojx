# Keil uVision project Project.uvprojx, settings and files
target Project (6210000::V6.21::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/App;../User/bsp;../User/Devices/emm42_v5;../User/Devices/LCD_Tjc;../User/Devices/Servo;../User/Devices/K230;../User/Devices/Ads1220
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group bsp
    ../User/bsp/: bsp_dwt.c bsp_dwt.h bsp_uart.c bsp_uart.h sys.c sys.h
  group Devices
    ../User/Devices/emm42_v5/: control.c control.h Emm_V5.c Emm_V5.h emm42_uart.c emm42_uart.h
    ../User/Devices/LCD_Tjc/: TJC.c TJC.h
    ../User/Devices/Servo/: Servo.c Servo.h
    ../User/Devices/K230/: K230.c K230.h
    ../User/Devices/Ads1220/: ads1220.c ads1220.h
  group App
    ../User/App/: hardware_config.c hardware_config.h USART_Callback.c USART_Callback.h Control_logic.c Control_logic.h
software components: CMSIS:CORE 5.6.0
